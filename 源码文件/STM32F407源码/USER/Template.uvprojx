# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --no_multibyte_chars
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\APP;..\LVGL;..\UI;..\LVGL\lvgl;..\USER;..\FWLIB\inc;..\HARDWARE\LCD;..\HARDWARE\TOUCH;..\HARDWARE\WM8978;..\HARDWARE\I2S;..\HARDWARE\IIC;..\HARDWARE\SDIO;..\FREEPTOS\include;..\FREEPTOS\portable\RVDS\ARM_CM4F;..\FATFS\src;..\FATFS\exfuns;..\Out Flash;..\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: Template.sct
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c fonts.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/I2S/: i2s.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
  group FreeRTOS_CODE
    ../FREEPTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PROTABLE
    ../FREEPTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FREEPTOS/portable/MemMang/: heap_4.c
    ../FREEPTOS/include/: FreeRTOSConfig.h
  group APP
    ../APP/: rtos_app.c rtos_app.h audio_app.c font_bin.c font_bin.h font_store.c font_store.h monitorPage.c soft_uart.c backlight.c wifi_app.c time_app.c uart_task.c spi_bus.c weather_app.c ime_kb.c ai_app.c
    ../LVGL/: lv_port_disp.c lv_port_indev.c
  group UI
    ../UI/: ui.c ui_helpers.c
    ../APP/: ui_user.c fs_lock.c utf16.c ffconv.c
    ../UI/fonts/: ui_font_Time.c ui_font_Week.c ui_font_monitorPage.c ui_font_Weather.c
    ../UI/components/: ui_comp_hook.c
    ../UI/images/: ui_img_267756134.c ui_img_344699915.c ui_img_387312750.c ui_img_408242217.c ui_img_782645969.c ui_img_853450402.c ui_img_862951715.c ui_img_933793681.c ui_img_1413029994.c ui_img_1680245803.c ui_temporary_image.c ui_img_365753981.c ui_img_1070165196.c ui_img_240510328.c ui_img_1887403499.c ui_img_808252844.c ui_img_417419544.c ui_img_843332074.c ui_img_944254084.c ui_img_745566655.c ui_img_1298347426.c
    ../UI/screens/: ui_Main.c ui_Music.c ui_MonitorPage.c ui_AIPage.c ui_SettingsPage.c ui_Weather_Page.c
  group LVGL
    ../LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL/lvgl/src/font/: lv_font_unscii_16.c lv_font_unscii_8.c lv_font_simsun_16_cjk.c lv_font_montserrat_48.c lv_font_montserrat_46.c lv_font_montserrat_44.c lv_font_montserrat_42.c lv_font_montserrat_40.c lv_font_montserrat_38.c lv_font_montserrat_36.c lv_font_montserrat_34.c lv_font_montserrat_32.c lv_font_montserrat_30.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_26.c lv_font_montserrat_24.c lv_font_montserrat_22.c lv_font_montserrat_20.c lv_font_montserrat_18.c lv_font_montserrat_16.c lv_font_montserrat_14.c lv_font_montserrat_12_subpx.c lv_font_montserrat_12.c lv_font_montserrat_10.c lv_font_montserrat_8.c lv_font_loader.c lv_font_fmt_txt.c lv_font_dejavu_16_persian_hebrew.c lv_font.c lv_font.h
    ../LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../LVGL/lvgl/src/extra/: lv_extra.c
    ../LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/lvgl/src/extra/widgets/win/: lv_win.c
  group Out Flash
    ../Out Flash/: spi.c w25qxx.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c
